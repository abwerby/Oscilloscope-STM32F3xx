# Keil uVision project O-Scope.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: O-Scope
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./: ADC_program.c DMA_program.c GPIO_program.c main.c RCC_program.c TFT_prog.c STK_program.c TIM2.c oscilloscope.c EXTI_program.c NVIC_program.c SYSCFG_program.c DAC_program.c
  group include
    ./: ADC_config.h ADC_interface.h ADC_private.h BIT_MATH.h DMA_config.h DMA_Interface.h DMA_private.h GPIO_config.h GPIO_interface.h GPIO_private.h RCC_config.h RCC_interface.h RCC_private.h STK_config.h STK_interface.h TFT_cfg.h TFT_Fonts.h TFT_Interface.h TFT_Privte.h TIM2.h oscilloscope.h EXTI_config.h EXTI_interface.h EXTI_private.h NVIC_config.h NVIC_interface.h NVIC_private.h SYSCFG_interface.h SYSCFG_private.h DAC_config.h DAC_interface.h DAC_private.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
